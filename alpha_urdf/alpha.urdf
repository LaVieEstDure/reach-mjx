Commit message: Fix inertia for body without geometry

File: alpha_urdf/alpha.urdf (robot description, URDF)
Before this commit: robot alpha_5_example, 12 links, 11 joints
Links:
- link alpha_jaws_base_link: mass 0.02 -> None
